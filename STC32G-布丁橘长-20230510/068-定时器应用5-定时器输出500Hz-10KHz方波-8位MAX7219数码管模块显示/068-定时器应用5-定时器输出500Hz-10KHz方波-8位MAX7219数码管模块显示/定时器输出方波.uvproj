# Keil uVision project 定时器输出方波.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: 定时器输出时钟 +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c MAX7219.c Delay.c
