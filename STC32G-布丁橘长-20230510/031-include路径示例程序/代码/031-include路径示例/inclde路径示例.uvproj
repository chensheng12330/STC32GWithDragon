# Keil uVision project inclde路径示例.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: include路径 +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c Delay.c
    ./Seg595/: Seg595.c
