# Keil uVision project stc_usb_cdc_dso.uvproj, settings and files
target dso (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: stc_usb_cdc_dso +hex
  link misc: REMOVEUNUSED
  group main
    ./src/: uart.c EEPROM.c OSCOPE-V1-12bit-CDC.c
  group usb
    ./src/usb/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
