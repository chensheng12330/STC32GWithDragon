# Keil uVision project FreeRTOS_STC32G_Demo.uvproj, settings and files
target FreeRTOS_STC32G_Demo (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: FreeRTOS_Demo +hex
  link misc: REMOVEUNUSED
  group FreeRTOS
    ./Sources/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group port
    ./Sources/FreeRTOS/portable/STC32G12K128/: port.c portmacro.h portasm.h
    ./Sources/FreeRTOS/portable/MemMang/: heap_1.c
  group user
    ./: 请先阅读本使用方法.txt
    ./Sources/User/include/: FreeRTOSConfig.h
    ./Sources/User/: main.c putchar.c System_init.c
  group task
    ./Sources/Task/src/: io.c can.c
  group driver
    ./Sources/Driver/src/: STC32G_ADC.c STC32G_CAN.c STC32G_Clock.c STC32G_Compare.c STC32G_Delay.c STC32G_DMA.c STC32G_EEPROM.c STC32G_Exti.c STC32G_GPIO.c STC32G_I2C.c STC32G_LCM.c STC32G_LIN.c STC32G_NVIC.c STC32G_PWM.c STC32G_RTC.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_Timer.c STC32G_UART.c STC32G_USART.c STC32G_WDT.c
  group isr
    ./Sources/Driver/isr/: STC32G_ADC_Isr.c STC32G_CAN_Isr.c STC32G_Compare_Isr.c STC32G_DMA_Isr.c STC32G_Exti_Isr.c STC32G_GPIO_Isr.c STC32G_I2C_Isr.c STC32G_LCM_Isr.c STC32G_LIN_Isr.c STC32G_PWM_Isr.c STC32G_RTC_Isr.c STC32G_SPI_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c
  group CANOpen
    ./Sources/CANOpen/src/: canfestival_can.c canfestival_timer.c dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ./Sources/CANOpen/objdict/: ObjDict.c
