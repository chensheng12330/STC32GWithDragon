# Keil uVision project config.uvproj, settings and files
target config (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: config +hex
  link misc: REMOVEUNUSED
  group Source
    ./: config.c
