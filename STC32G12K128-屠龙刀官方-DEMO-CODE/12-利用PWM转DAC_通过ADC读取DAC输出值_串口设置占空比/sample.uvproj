# Keil uVision project sample.uvproj, settings and files
target Sample (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: sample +hex
  group Source
    ./: main.c
    ../COMM/: stc_usb_hid_32.LIB
