# Keil uVision project STC32G_CANOpen.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G_CANOpen +hex
  link misc: REMOVEUNUSED
  group user
    ./User/: main.c System_init.c Task.c APP_CAN.c putchar.c APP_KEY.c
  group driver
    ./Driver/src/: STC32G_CAN.c STC32G_GPIO.c STC32G_NVIC.c STC32G_Timer.c STC32G_UART.c
  group isr
    ./Driver/isr/: STC32G_CAN_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c
  group CANOpen
    ./CANOpen/src/: canfestival_can.c dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ./CANOpen/objdict/: ObjDict.c
