# Keil uVision project Mini DSO.uvproj, settings and files
target Mini_DSO (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Mini DSO +hex
  group main
    ./: main.c delay.c settings.c ssd1306.c eeprom.c chart.c global.c adc_stc.c
  group debug
    ./: interface.c uart.c
